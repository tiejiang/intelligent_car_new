# Keil uVision project NEW_TEMPLATE.uvproj, settings and files
target NEW_TEMPLATE (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NEW_TEMPLATE +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32F10X_FWLIB\inc;..\USER;..\SYSTEM\sys;..\SYSTEM\usart;..\SYSTEM\delay;..\HARDWARE\INFRARED_SAFE_DISTANCE;..\HARDWARE\INFRARED_TRACKING;..\HARDWARE\MOTOR;..\HARDWARE\System_LED;..\HARDWARE\TIMER;..\HARDWARE\Nokia510;..\HARDWARE\HMC5883L;..\HARDWARE\Ultrasonic;..\HARDWARE\Dijkstra;..\HARDWARE\Dynamic_Map
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group STM32F10X_FWLIB
    ../STM32F10X_FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/delay/: delay.c
  group Infrared_tracking
    ../HARDWARE/INFRARED_TRACKING/: infrared_tracking.c
  group Infrared_safedistance
    ../HARDWARE/INFRARED_SAFE_DISTANCE/: InfraredSafeDistance.c
  group System_led
    ../HARDWARE/System_LED/: led.c
  group Motor
    ../HARDWARE/MOTOR/: motor.c
  group Timer
    ../HARDWARE/TIMER/: timer.c TIM5_Obstacle_Detect.c
  group HMC5883L
    ../HARDWARE/HMC5883L/: HMC5883L.c
  group Nokia5110
    ../HARDWARE/Nokia510/: LCD5110.C
  group Ultrasonic
    ../HARDWARE/Ultrasonic/: ultrasonic.c
  group Dijkstra
    ../HARDWARE/Dijkstra/: Dijkstra.c
  group Dynamic_Map
    ../HARDWARE/Dynamic_Map/: Dynamic_Map.c
